# Keil uVision project SPI通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SPI通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c LCD1602.c LCD1602.h Delay.c Delay.h Key.c Key.h Timer0.c Timer0.h
